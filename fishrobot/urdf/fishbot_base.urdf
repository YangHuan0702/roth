Commit message: Update fishbot_base.urdf

File: fishrobot/urdf/fishbot_base.urdf (robot description, URDF)
Before this commit: robot fishbot, 7 links, 6 joints
Links:
- link base_link: mass None -> 0.2; geometry collision cylinder length=0.12 radius=0.10; visual cylinder length=0.12 radius=0.10
